# Keil uVision project RemoteControlCar.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: RemoteControlCar +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 start.c MoveCar.c DELAY.c MoveCar.h DELAY.h DefineVar.h UART.c UART.h SpeedDisplay.c SpeedDisplay.h Wireless433M.c Wireless433M.h
