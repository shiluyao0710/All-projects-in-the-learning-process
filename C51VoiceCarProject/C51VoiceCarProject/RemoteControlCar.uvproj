# Keil uVision project RemoteControlCar.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: RemoteControlCar +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 start.c MoveCar.c MoveCar.h DELAY.h Track.c Track.h Follow.c Follow.h IIC.c IIC.h OLED.c OLED.h Oledfont.h SG90.c SG90.h HCSR04.c HCSR04.h ObstacleAvoidance.c ObstacleAvoidance.h LEDRGB.c LEDRGB.h buzzer.c buzzer.h SU03T.c SU03T.h UART.c UART.h TTLDefine.h DELAY.c
